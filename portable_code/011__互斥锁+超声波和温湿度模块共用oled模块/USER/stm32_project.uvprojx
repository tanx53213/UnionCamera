# Keil uVision project stm32_project.uvprojx, settings and files
target PROJECT (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\ST_LIB\inc;..\SYSTEM\delay;..\SYSTEM\uart;..\MYM4_LIB\buzzer;..\MYM4_LIB\key;..\MYM4_LIB\led;..\FreeRTOS\include;..\FreeRTOS;..\FreeRTOS\port;..\MYM4_LIB\dht11;..\MYM4_LIB\hc_sr04;..\MYM4_LIB\hs0038;..\MYM4_LIB\iic_oled;..\MYM4_LIB\spi_mfrc522
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c my_config.c my_lib.c my_reg.c
  group M4M4_LIB
    ../MYM4_LIB/buzzer/: buzzer.c
    ../MYM4_LIB/key/: key.c
    ../MYM4_LIB/led/: led.c
    ../MYM4_LIB/dht11/: dht11.c
    ../MYM4_LIB/hc_sr04/: hc_sr04.c
    ../MYM4_LIB/iic_oled/: iic_oled.c iic_oled_bmp.c iic_oled_font.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/uart/: uart.c
  group ST_LIB
    ../ST_LIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group CJSON
    ../CJSON/: cJSON.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/: heap_4.c port.c
