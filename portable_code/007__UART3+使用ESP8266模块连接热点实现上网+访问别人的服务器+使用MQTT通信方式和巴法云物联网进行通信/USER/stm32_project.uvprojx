# Keil uVision project stm32_project.uvprojx, settings and files
target PROJECT (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\ST_LIB\inc;..\SYSTEM\delay;..\SYSTEM\uart;..\CJSON;..\MYM4_LIB\buzzer;..\MYM4_LIB\dht11;..\MYM4_LIB\esp8266;..\MYM4_LIB\exti;..\MYM4_LIB\key;..\MYM4_LIB\led;..\MYM4_LIB\timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c my_config.c my_lib.c my_reg.c
  group M4M4_LIB
    ../MYM4_LIB/buzzer/: buzzer.c
    ../MYM4_LIB/dht11/: dht11.c
    ../MYM4_LIB/esp8266/: esp8266.c esp8266_bemfayun_mqtt.c esp8266_bemfayun_tcp.c esp8266_gettime.c esp8266_getweather.c
    ../MYM4_LIB/key/: key.c
    ../MYM4_LIB/led/: led.c
    ../MYM4_LIB/timer/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/systick_it/: systick_it.c
    ../SYSTEM/uart/: uart.c
  group ST_LIB
    ../ST_LIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group CJSON
    ../CJSON/: cJSON.c
